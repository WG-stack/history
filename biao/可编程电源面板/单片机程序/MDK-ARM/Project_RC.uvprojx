# Keil uVision project Project_RC.uvprojx, settings and files
target Project_RC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project_RC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./USER_HARDWARE/FUNCTION;./USER_HARDWARE/AT24C64;./USER_HARDWARE/BCD;./USER_HARDWARE/RX8025T;./USER_HARDWARE/AD_DA;./USER_HARDWARE/USART;./USER_HARDWARE/CMD_INPUT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HAREWARE
    ./USER_HARDWARE/FUNCTION/: function.c
    ./USER_HARDWARE/AT24C64/: at24c64.c
    ./USER_HARDWARE/BCD/: bcd_output.c
    ./USER_HARDWARE/RX8025T/: rx8025t.c
    ./USER_HARDWARE/AD_DA/: ad_da.c
    ./USER_HARDWARE/USART/: fiber_485_usart.c hmi_usart.c rs485_usart.c
    ./USER_HARDWARE/CMD_INPUT/: cmd_input.c
software components: CMSIS:CORE 4.3.0
