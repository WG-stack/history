# Keil uVision project New Folder.uvprojx, settings and files
target New Folder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: New Folder +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L152xC
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l152xc.s
  group Application/User/Core
    ../Core/Src/: gpio.c adc.c dma.c lcd.c rtc.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c key_driver.c main.c usb_app.c system_stm32l1xx.c lcd_display.c lcd_driver.c data_processing.c sensor_sample.c global_variables.c measurement_state_machine.c
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_tim.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_adc.c stm32l1xx_ll_dma.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_lcd.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c
software components: CMSIS:CORE 4.3.0
